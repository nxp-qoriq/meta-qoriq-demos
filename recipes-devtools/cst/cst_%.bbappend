SRC_URI = "git://bitbucket.sw.nxp.com/scm/sdk/cst.git;branch=master;protocol=https"
SRCREV = "ac8c66cd7e19a9214dbf8bd9bd27077a95d43718"
