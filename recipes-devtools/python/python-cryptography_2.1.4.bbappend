LDFLAGS_append = " -pthread"
