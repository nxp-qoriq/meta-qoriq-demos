FILESEXTRAPATHS_append := "${THISDIR}/${PN}"
SRC_URI += "file://0001-qemu-virtio-net-pci-instead-of-virtio-net-device.patch \
"
