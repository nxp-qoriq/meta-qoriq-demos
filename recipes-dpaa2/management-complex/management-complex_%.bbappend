LICENSE = "NXP-Binary-EULA"
LIC_FILES_CHKSUM = "file://NXP-Binary-EULA.txt;md5=afcb1213054384820390d410ab62105f"

SRC_URI = "git://bitbucket.sw.nxp.com/scm/dpaa2/mc-binary.git;branch=lx2160a;protocol=https"
SRCREV = "736a485535fa8593aff66b2f2584d4b32eb68838"
