SRC_URI = "git://source.codeaurora.org/external/qoriq/qoriq-components/restool;nobranch=1"
SRCREV = "9b625543b08a1310a826755bde372542414c2122"

COMPATIBLE_MACHINE = "(ls2080ardb|ls2088ardb|ls1088ardb|lx2160a)"
