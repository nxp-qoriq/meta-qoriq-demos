SRC_URI = "git://bitbucket.sw.nxp.com/scm/dnnpi/lx2-uboot.git;branch=lx2-devel;protocol=https"
SRCREV = "3db02c907ed469c49f6668cea3cbfa910727ac33"
