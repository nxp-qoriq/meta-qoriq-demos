SRCREV= "70fa519d85ba8185015102eb0bf92f3802143072"

addtask deploy before do_populate_sysroot after do_install
